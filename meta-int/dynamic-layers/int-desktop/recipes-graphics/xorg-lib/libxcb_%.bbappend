# Hyprland (int-image-osint-hyprland) links libXcursor. INT has no X11 server:
# only this client library chain is allowed, not the x11 distro feature.
REQUIRED_DISTRO_FEATURES = ""
